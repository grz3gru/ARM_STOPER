# Keil uVision project keil_project_JK_GG.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keil_project_JK_GG
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group New Group
    ./Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    ./Core/Inc/: main.h stm32f1xx_hal_conf.h stm32f1xx_it.h
